# Keil uVision project Project.uvprojx, settings and files
target STM32F103C8T6 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../Drivers/STM32F1xx_HAL_Driver/Inc;../u8g2/csrc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329  --remove
  group Drivers/STM32F1xx_HAL_Driver
    ../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio.c stm32f1xx_hal_wwdg.c stm32f1xx_hal_flash.c stm32f1xx_hal_crc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_nand.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_pcd.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_ll_usb.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_eth.c stm32f1xx_hal_rtc.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_sd.c stm32f1xx_hal_i2s.c stm32f1xx_hal_spi.c stm32f1xx_hal_rcc.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_sram.c stm32f1xx_hal_nor.c stm32f1xx_hal_usart.c stm32f1xx_hal_adc.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_dac.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_irda.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal.c stm32f1xx_hal_pccard.c stm32f1xx_hal_mmc.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_utils.c
  group Example/User
    ../Src/: stm32f1xx_hal_msp.c main.c stm32f1xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Example/MDK-ARM
    ./: startup_stm32f103xb.s
  group u8g2
    ../u8g2/csrc/: u8x8_u16toa.c u8x8_u8toa.c u8x8_string.c u8x8_setup.c u8x8_selection_list.c u8x8_message.c u8x8_input_value.c u8x8_gpio.c u8x8_fonts.c u8x8_display.c u8x8_debounce.c u8x8_d_st7920.c u8x8_cad.c u8x8_byte.c u8x8_8x8.c u8g2_selection_list.c u8g2_polygon.c u8g2_message.c u8g2_ll_hvline.c u8g2_line.c u8g2_kerning.c u8g2_intersection.c u8g2_input_value.c u8g2_hvline.c u8g2_font.c u8g2_cleardisplay.c u8g2_circle.c u8g2_buffer.c u8g2_box.c u8g2_bitmap.c u8g2_fonts.c u8g2_d_memory.c u8g2_d_setup.c u8g2_setup.c
software components: CMSIS:CORE 5.0.2
